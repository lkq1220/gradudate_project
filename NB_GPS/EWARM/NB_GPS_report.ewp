# IAR project NB_GPS_report.ewp, settings and files
configuration NB_GPS_report (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RC ST STM32L476RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L476xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ..\Src\Display; ..\Src\GY_JSON; ..\Src\KEY; ..\Src\Led_Blink; ..\Src\NBxxModule; ..\Src\GPS_Parse; ..\Src\UART_DMA_CFG; E:\NB-IOT\GPS_ok\NB_GPS\Src\sht20_cfg; E:\NB-IOT\GPS_ok\NB_GPS\Src\UART_DMA_CFG; E:\NB-IOT\GPS_ok\NB_GPS\Src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: NB_GPS_report.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Display
    ../Src/Display/: Display.c Display.h DisplayTFT128.c DisplayTFT128.h lcd_base.h LCDDogm1286_util.c LCDDogm1286_util.h TFT128.c TFT128.h
  group Application/EWARM
    ./: startup_stm32l476xx.s
  group Application/GPSParse
    ../Src/GPS_Parse/: gps_l70_r.c gps_l70_r.h
  group Application/GY_JSON
    ../Src/GY_JSON/: json_format.c json_format.h
  group Application/KEY
    ../Src/KEY/: key_handle.c key_handle.h
    ../Src/NBxxModule/: NB_Board.h
  group Application/LedBlink
    ../Src/Led_Blink/: led_blink.c led_blink.h
  group Application/NBxx
    ../Src/NBxxModule/: NB_BC95.c NB_BC95.h NB_Board.c NB_Board_Cfg.c NB_Board_Cfg.h nb_types.h
  group Application/SHT20_CFG
    ../Src/sht20_cfg/: sht20_cfg.c sht20_cfg.h
  group Application/UartDma
    ../Src/UART_DMA_CFG/: _dma_cfg.c _dma_cfg.h
  group Application/User
    ../Src/: adc.c dma.c gpio.c i2c.c main.c spi.c stm32l4xx_hal_msp.c stm32l4xx_it.c timer_user_poll.c usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
